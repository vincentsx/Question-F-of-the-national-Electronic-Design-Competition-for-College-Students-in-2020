# IAR project Template.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllff.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEBUG; RAM_VECTOR
  ICC430.newCCIncludePaths: $PROJ_DIR$; Drivers\inc; Drivers\src; Drivers\src\USB; Drivers\src\USB\USB_config; Drivers\src\USB\USB_User; Drivers\srcUSB\USB_API\USB_CDC_API; Drivers\src\USB\USB_API\USB_HID_API; Drivers\src\USB\USB_API\USB_MSC_API; HardWare; HardWare\delay; HardWare\18b20; HardWare\KEY; HardWare\LED; HardWare\12864; HardWare\oled; HardWare\mpu6050\inc; HardWare\mpu6050\src; HardWare\nokia5110\inc; HardWare\nokia5110\src; HardWare\LQ_1.8_TFT; HardWare\LCD_API; HardWare\2.2TFT; HardWare\nrf24l01; System; System\inc; System\src; User; User\USER; Lib\UCOSII\CONFIG; Lib\uCOSII\App; Lib\uCOSII\CONFIHG; Lib\uCOSII\PORT; Lib\UCOSII\CORE; Lib\FatFs; Lib\FatFs\option; G:\比赛\2020电赛\MSP430F5529库函数2.6\MSP430F5529库函数2.6\C版\工程模板\User\USER
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 2
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  ICC430.CCDefines: NDEBUG; RAM_VECTOR
  ICC430.newCCIncludePaths: $PROJ_DIR$; Drivers\inc; Drivers\src; Drivers\src\USB; Drivers\src\USB\USB_config; Drivers\src\USB\USB_User; Drivers\srcUSB\USB_API\USB_CDC_API; Drivers\src\USB\USB_API\USB_HID_API; Drivers\src\USB\USB_API\USB_MSC_API; HardWare\KEY; HardWare\LED; HardWare\12864; HardWare\oled; HardWare\mpu6050\inc; HardWare\mpu6050\src; HardWare\nokia5110\inc; HardWare\nokia5110\src; HardWare\LQ_1.8_TFT; HardWare\LCD_API; HardWare\2.2TFT; HardWare\delay; System; System\inc; System\src; User; User\USER; Lib\UCOSII\CONFIG; Lib\uCOSII\App; Lib\uCOSII\CONFIHG; Lib\uCOSII\PORT; Lib\UCOSII\CORE; Lib\FatFs; Lib\FatFs\option
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group HardWare
    HardWare/delay/: delay.c delay.h
    HardWare/KEY/: KEY.c KEY.h
    HardWare/2.2TFT/: LCD.c LCD.h
    HardWare/LCD_API/: LCD_API.c LCD_API.h
    HardWare/LED/: LED.c LED.h
    HardWare/nrf24l01/: nrf2401.c nrf2401.h
    HardWare/oled/: OLED.c OLED.h
  group Lib/FatFs
    Lib/FatFs/: diskio.h ff.c ff.h ffconf.h mmc.c mmc.h
  group Lib/uCOS-II/CONFIG
    Lib/UCOSII/CONFIG/: includes.h os_cfg.h
  group Lib/uCOS-II/CORE
    Lib/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group Lib/uCOS-II/PORT
    Lib/UCOSII/PORT/: os_cpu.h os_cpu_a.s43 os_cpu_c.c os_dbg.c
  group StdPeriph_Driver
    Drivers/src/: msp430f5529_adc.c msp430f5529_clock.c msp430f5529_compater.c msp430f5529_dma.c msp430f5529_flash.c msp430f5529_gpio.c msp430f5529_i2c.c msp430f5529_lpm.c msp430f5529_nmi.c msp430f5529_remap.c msp430f5529_rtc.c msp430f5529_spi.c msp430f5529_timer.c msp430f5529_uart.c msp430f5529_watchdog.c
    Drivers/inc/: msp430f5529_adc.h msp430f5529_clock.h msp430f5529_compater.h msp430f5529_dma.h msp430f5529_flash.h msp430f5529_gpio.h msp430f5529_i2c.h msp430f5529_lpm.h msp430f5529_nmi.h msp430f5529_remap.h msp430f5529_rtc.h msp430f5529_spi.h msp430f5529_timer.h msp430f5529_uart.h msp430f5529_watchdog.h
    System/src/: msp430f5529_vectors.c
    System/inc/: msp430f5529_vectors.h
  group System
    System/src/: assert.c startup_msp430f5529.c
    System/inc/: common.h include.h msp430f5529_system.h
  group User
    User/: main.c
    System/src/: msp430f5529_it.c
  group User/User
    User/USER/: Filter.c Filter.h LMT70.c LMT70.h logxxx.c logxxx.h PID.c PID.h
